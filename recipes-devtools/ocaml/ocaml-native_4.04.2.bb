require ocaml-4.04.inc
inherit native
