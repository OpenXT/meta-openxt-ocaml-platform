require findlib-${PV}.inc

BBCLASSEXSTEND = "native"
